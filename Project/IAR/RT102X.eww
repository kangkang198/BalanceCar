<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\program\RT102X.ewp</path>
    </project>
    <batchBuild />
</workspace>
